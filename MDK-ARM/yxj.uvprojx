# Keil uVision project yxj.uvprojx, settings and files
target Application_A (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F071xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.20
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: yxj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F071xB,APPLICATION_A_BUILD
  c include: ..\Core\Inc;..\Platform\CMSIS\Include;..\Platform\CMSIS\Device\PY32F071\Include;..\Platform\PY32F071_HAL_Driver\Inc;..\Middlewares\FreeRTOS\Source\include;..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\App;..\BSP;..\Service;..\Driver;..\boot
  memory RVCT4: ROM 0x8004000 size 0xd800
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../core/Startup/: startup_py32f071xx.s
  group CORE
    ../core/Src/: main.c py32f071_hal_msp.c py32f071_hal_timebase_tim.c py32f071_it.c system_py32f071.c
  group HAL
    ../Platform/PY32F071_HAL_Driver/Src/: py32f071_hal.c py32f071_hal_adc.c py32f071_hal_adc_ex.c py32f071_hal_comp.c py32f071_hal_cortex.c py32f071_hal_crc.c py32f071_hal_ctc.c py32f071_hal_dac.c py32f071_hal_dac_ex.c py32f071_hal_div.c py32f071_hal_dma.c py32f071_hal_exti.c py32f071_hal_flash.c py32f071_hal_gpio.c py32f071_hal_i2c.c py32f071_hal_i2s.c py32f071_hal_irda.c py32f071_hal_iwdg.c py32f071_hal_lcd.c py32f071_hal_lptim.c py32f071_hal_opa.c py32f071_hal_opa_ex.c py32f071_hal_pwr.c py32f071_hal_rcc.c py32f071_hal_rcc_ex.c py32f071_hal_rtc.c py32f071_hal_rtc_ex.c py32f071_hal_smartcard.c py32f071_hal_spi.c py32f071_hal_tim.c py32f071_hal_tim_ex.c py32f071_hal_uart.c py32f071_hal_usart.c py32f071_hal_wwdg.c
  group Middlewares
    ../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group BSP
    ../BSP/: bsp_gpio.c bsp_iic.c bsp_init.c bsp_usart.c
  group Driver
    ../Driver/: driver_main.c key.c mpu_6050.c oled.c ota_uart.c ble.c
  group service
    ../Service/: service_display.c service_enmu.c service_main.c service_mpu_6050.c ota_protocol.c ota_receiver.c
  group App
    ../App/: app_main.c app_settings.c game_arcade.c game_snake.c game_dino.c game_manager.c game_util.c
  group boot
    ../boot/: boot_mian.c boot_jump.c boot_flash.c boot_it.c boot_config.h boot_select.c boot_metadata.c boot_crc.c app_update.c
target Application_B (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F071xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.20
  cpu: as above
  output: yxj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F071xB,APPLICATION_B_BUILD
  c include: as above
  memory RVCT4: ROM 0x8011800 size 0xd800
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F071xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.20
  cpu: as above
  output: yxj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F071xB,BOOTLOADER_BUILD
  c include: ..\Core\Inc;..\Platform\CMSIS\Include;..\Platform\CMSIS\Device\PY32F071\Include;..\Platform\PY32F071_HAL_Driver\Inc;..\Middlewares\FreeRTOS\Source\include;..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\App;..\BSP;..\Service;..\Driver
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
